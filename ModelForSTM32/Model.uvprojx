# Keil uVision project Model.uvprojx, settings and files
target generator_control_panel V1.0 (ARM-ADS)
  device: STM32F101CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Model
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Applications;.\Core;.\Devices;.\Drivers;.\Libraries\STM32F10x_FWLib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications
    ./Applications/: main.c init.c init.h scheduler.c scheduler.h
  group Devices
    ./Devices/: device_timer.c device_timer.h device_led.c device_led.h device_pwm_out.c device_pwm_out.h
  group Drivers
    ./Drivers/: driver_led.c driver_led.h driver_time.c driver_time.h driver_pwm_out.c driver_pwm_out.h
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_md.s
  group Libraries
    ./Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: stm32f10x_it.c system_stm32f10x.c
